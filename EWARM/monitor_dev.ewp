# IAR project monitor_dev.ewp, settings and files
configuration monitor_dev (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\DHT11; ..\GPRS; ..\app; ..\SGP30; ..\freeRTOS; ..\freeRTOS\include; ..\freeRTOS\portable
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\freeRTOS
  OBJCOPY.OOCOutputFile: monitor_dev.hex
  ILINK.IlinkOutputFile: monitor_dev.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: adc.c gpio.c main.c my_mktime.c rtc.c stm32f1xx_hal_msp.c stm32f1xx_it.c usart.c
  group Application/User/APP
    ../app/: lowPower.c proc.c
  group Application/User/dht11
    ../DHT11/: dht11_app.c dht11_bsp.c
  group Application/User/GPRS
    ../GPRS/: gprs_app.c gprs_bsp.c
  group Application/User/sgp30
    ../SGP30/: sgp30_app.c sgp30_bsp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group FreeRTOS
    ../freeRTOS/: freeRTOS_Entrance.c
  group FreeRTOS/portable
    ../freeRTOS/portable/: port.c portasm.s
  group FreeRTOS/src
    ../freeRTOS/src/: croutine.c event_groups.c heap_4.c list.c queue.c stream_buffer.c tasks.c timers.c
